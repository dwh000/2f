# Keil uVision project wkb-2f.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F060 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: 2F-0-1001 +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 24c04.c disp.c key_func.c main.c menu_func.c public.c timer.c weighting.c terminal.c
  group txt
    ./: 2F微机程序开发文档.txt
